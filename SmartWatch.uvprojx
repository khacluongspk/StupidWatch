# Keil uVision project SmartWatch.uvprojx, settings and files
target SmartWatch (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SmartWatch
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_CUSTOM S130 GPIOTE_ENABLED S130 BLE_STACK_SUPPORT_REQD NRF51822 BOARD_PCA10028 S130 NRF_SD_BLE_API_VERSION=2 NRF51 SOFTDEVICE_PRESENT
  c include: ..\keil_source
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
  group Source
    ./: main.c uart_module.c mpu6050.c ssd1306.c
software components: CMSIS:CORE 5.0.1, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.12.0, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advertising 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_state 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:gatt_cache_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:gattc_cache_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:gatts_cache_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:id_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_data 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_data_storage 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_database 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_id 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:pm_buffer 4.0.0-2.alpha, nRF_BLE:BLE_Modules:pm_mutex 4.0.0-2.alpha, nRF_BLE:BLE_Modules:security_dispatcher 4.0.0-2.alpha, nRF_BLE:BLE_Modules:security_manager 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_bas 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_rscs 4.0.0-2.alpha, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_drv_rtc 4.0.0-2.alpha, nRF_Drivers:nrf_drv_timer 4.0.0-2.alpha, nRF_Drivers:nrf_drv_twi 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_rtc 4.0.0-2.alpha, nRF_Drivers:nrf_timer 4.0.0-2.alpha, nRF_Drivers:nrf_twi 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:app_button 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_fifo 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_trace 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:experimental_section_vars 4.0.0-2.alpha, nRF_Libraries:fds 4.0.0-2.alpha, nRF_Libraries:fstorage 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:nrf_log 4.0.0-2.alpha, nRF_Libraries:retarget 4.0.0-2.alpha, nRF_Libraries:sdk_mapped_flags 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s130 2.0.0-7.alpha
